# Keil uVision project bluetooth_stack_nortos.uvprojx, settings and files
target bluetooth_stack_nortos (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: bluetooth_stack_nortos +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\..\..\platform\uart;..\..\..\source\stack;..\..\..\platform\uart;..\..\..\utils\fifo;..\..\..\utils\timer;..\..\..\Third_party\crypto\include;..\..\..\source\Server;..\..\..\platform\stm32f103
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group TinyBLE/Src
    ../../../source/stack/: att.c gap.c gatt.c hci.c l2cap.c smp.c smp_key.c
  group TinyBLE/utils
    ../../../utils/fifo/: fifo.c
    ../../../utils/timer/: tiny_timer.c
  group ThirdParty
    ../../../Third_party/crypto/source/: aes_encrypt.c utils.c cmac_mode.c
  group TinyBLE/Src/services
    ../../../source/Server/: Server.c
    ../../../source/Server/rdtss/: rdtss.c
    ../../../source/Server/Name/: ble_app_name.c
    ../../../source/Server/Hid_mouse/: hid_mouse.c
    ../../../source/Server/Heart_Rate/: Heart_Rate.c
    ../../../source/Server/Battery/: Battery.c
  group Platform
    ../../../platform/stm32f103/: phy_h4.c
software components: CMSIS:CORE 4.3.0
